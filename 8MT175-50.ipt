# Autodesk Inventor part: 8MT175-50
## iProperties
Created: 2008-09
Part Number: 8MT175-50
Document SubType Name: Modeling
Designer: Darius
Author: Darius
